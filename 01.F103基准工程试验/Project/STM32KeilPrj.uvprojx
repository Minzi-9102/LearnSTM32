# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\Material.V2.0\01.F103基准工程实验\App\Main;..\..\..\Material.V2.0\01.F103基准工程实验\App\LED;..\..\..\Material.V2.0\01.F103基准工程实验\App\DataType;..\..\..\Material.V2.0\01.F103基准工程实验\HW\RCC;..\..\..\Material.V2.0\01.F103基准工程实验\HW\Timer;..\..\..\Material.V2.0\01.F103基准工程实验\HW\UART1;..\..\..\Material.V2.0\01.F103基准工程实验\FW\inc;..\..\..\Material.V2.0\01.F103基准工程实验\ARM\NVIC;..\..\..\Material.V2.0\01.F103基准工程实验\ARM\SysTick;..\..\..\Material.V2.0\01.F103基准工程实验\ARM\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: Queue.c UART1.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group ARM
    ../ARM/System/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s core_cm3.c
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
